!  2-Port S-parameters saved by WinCal
! VAR MeasName=S-Parameters (CALIBRATED_DATA) read from VNA (N5244A)
! VAR MeasDate=5/25/2013 11:23:16 AM
! VAR NAME=132606 2
! VAR FILENAME=132606 2.S2P
! VAR DATE=5/25/2013 11:23:17 AM
! VAR PHYS_PORTS=1,2
# Hz S MA R 50
! Worked out from all points (weakly coupled two-port):
!   801 points, 100 MHz to 40 GHz, reference 50 ohm
!   highest |S21| = -21.90 dB at 39.95 GHz (marker M1); lowest = -72.6 dB at 149.9 MHz (marker M2)
!   lowest |S11| = -26.9 dB at 9.427 GHz (marker M3), VSWR 1.09, Z = 53.4 - j3.27 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -6.4 to -3.1 dB; largest |S21 - S12| = 0.0035
!   the Smith chart shows 6.584 GHz to 11.12 GHz only
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 100 MHz  -16.4  -68.9  -71.9  -3.1
! 149.9 MHz  -16.3  -72.6  -67.4  -3.1
! 798.2 MHz  -18.0  -57.5  -57.0  -3.1
! 1.846 GHz  -16.9  -49.3  -49.9  -3.1
! 4.19 GHz  -12.1  -41.9  -42.2  -3.2
! 5.038 GHz  -22.5  -41.2  -41.3  -3.3
! 6.783 GHz  -16.7  -38.5  -38.5  -3.4
! 8.479 GHz  -11.2  -35.8  -35.9  -3.5
! 9.427 GHz  -26.9  -35.9  -35.8  -3.6
! 10.32 GHz  -11.7  -34.4  -34.5  -3.7
! 11.97 GHz  -23.3  -34.1  -34.2  -3.8
! 13.42 GHz  -13.9  -32.8  -33.0  -4.0
! 20.05 GHz  -14.1  -29.6  -29.3  -4.6
! 22.69 GHz  -19.8  -28.8  -28.8  -4.8
! 24.89 GHz  -11.6  -27.2  -27.4  -5.0
! 26.73 GHz  -18.6  -26.8  -27.0  -5.2
! 27.93 GHz  -12.4  -26.1  -26.3  -5.3
! 29.48 GHz  -20.0  -25.8  -26.1  -5.5
! 33.37 GHz  -17.6  -23.8  -23.9  -6.0
! 38.4 GHz  -11.3  -22.1  -22.3  -6.4
! 39.95 GHz  -15.5  -21.9  -22.1  -6.4
! 40 GHz  -17.4  -22.0  -22.0  -6.4
